# Keil uVision project EPD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: EPD +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\EPD;..\HARDWARE\Fonts;..\HARDWARE\GUI;..\HARDWARE\FT6336;..\HARDWARE\I2C;..\HARDWARE\LED;..\HARDWARE\GT911
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_exti.c
  group EPD
    ../HARDWARE/EPD/: Display_EPD_W21.c Display_EPD_W21_spi.c
  group GUI
    ../HARDWARE/GUI/: GUI_Paint.c
  group FONTS
    ../HARDWARE/Fonts/: font8.c font12.c font12CN.c font16.c font20.c font24.c font24CN.c
  group TOUCH
    ../HARDWARE/LED/: led.c
    ../HARDWARE/GT911/: gt9xx.c
    ../HARDWARE/I2C/: iic.c
